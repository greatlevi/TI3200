<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>ZC</name>
    <group>
      <name>inc</name>
      <group>
        <name>aes</name>
        <file>
          <name>$PROJ_DIR$\ZC\inc\aes\aes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\inc\aes\aes_locl.h</name>
        </file>
      </group>
      <group>
        <name>tropicssl</name>
        <file>
          <name>$PROJ_DIR$\ZC\inc\tropicssl\bignum.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\inc\tropicssl\bn_mul.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\inc\tropicssl\rsa.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\inc\tropicssl\secconfig.h</name>
        </file>
      </group>
      <group>
        <name>zc</name>
        <file>
          <name>$PROJ_DIR$\ZC\inc\zc\zc_bc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\inc\zc\zc_client_manager.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\inc\zc\zc_cloud_event.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\inc\zc\zc_common.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\inc\zc\zc_configuration.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\inc\zc\zc_message_queue.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\inc\zc\zc_module_config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\inc\zc\zc_module_interface.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\inc\zc\zc_protocol_controller.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\inc\zc\zc_protocol_interface.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\inc\zc\zc_sec_engine.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\inc\zc\zc_timer.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>src</name>
      <group>
        <name>aes</name>
        <file>
          <name>$PROJ_DIR$\ZC\src\aes\aes_cbc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\src\aes\aes_core.c</name>
        </file>
      </group>
      <group>
        <name>crc</name>
        <file>
          <name>$PROJ_DIR$\ZC\src\crc\crc.c</name>
        </file>
      </group>
      <group>
        <name>tropicssl</name>
        <file>
          <name>$PROJ_DIR$\ZC\src\tropicssl\bignum.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\src\tropicssl\rsa.c</name>
        </file>
      </group>
      <group>
        <name>zc</name>
        <file>
          <name>$PROJ_DIR$\ZC\src\zc\zc_bc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\src\zc\zc_client_manager.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\src\zc\zc_cloud_event.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\src\zc\zc_common.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\src\zc\zc_configuration.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\src\zc\zc_message_queue.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\src\zc\zc_moudle_manager.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\src\zc\zc_protocol_controller.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\src\zc\zc_sec_engine.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\ZC\src\zc\zc_timer.c</name>
        </file>
      </group>
    </group>
  </group>
  <file>
    <name>$PROJ_DIR$\gpio_if.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\gpio_if.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\startup_ewarm.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\uart_if.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\uart_if.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\zc_ti_adpter.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\zc_ti_adpter.h</name>
  </file>
</project>


