# IAR project ti3200.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED; ZC_MODULE_VERSION=0; ZC_MODULE_TYPE=8
  ICCARM.CCIncludePath2: $PROJ_DIR$; ZC/inc/aes; ZC/inc/tropicssl; ZC/inc/zc; ../middleware/framework/pm/; ../middleware/framework/timer/; ../middleware/driver/; ../middleware/driver/hal/; ../driverlib/; ../inc/; ../oslib/; ../third_party/FreeRTOS/source/; ../third_party/FreeRTOS/source/include/; ../third_party/FreeRTOS/source/portable/IAR/ARM_CM4/; ../simplelink; ../simplelink/source; ../simplelink/include; ../simplelink_extlib/flc; ../example/common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ti3200.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\TexasInstruments\cc3200.icf
  ILINK.IlinkAdditionalLibs: ../oslib/ewarm/free_rtos/Exe/free_rtos.a; ../driverlib/ewarm/Release/Exe/driverlib.a; ../simplelink/ewarm/OS/Exe/simplelink.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: gpio_if.c gpio_if.h main.c startup_ewarm.c uart_if.c uart_if.h zc_ti_adpter.c zc_ti_adpter.h
  group ZC/inc/aes
    ZC/inc/aes/: aes.h aes_locl.h
  group ZC/inc/tropicssl
    ZC/inc/tropicssl/: bignum.h bn_mul.h rsa.h secconfig.h
  group ZC/inc/zc
    ZC/inc/zc/: zc_bc.h zc_client_manager.h zc_cloud_event.h zc_common.h zc_configuration.h zc_message_queue.h zc_module_config.h zc_module_interface.h zc_protocol_controller.h zc_protocol_interface.h zc_sec_engine.h zc_timer.h
  group ZC/src/aes
    ZC/src/aes/: aes_cbc.c aes_core.c
  group ZC/src/crc
    ZC/src/crc/: crc.c
  group ZC/src/tropicssl
    ZC/src/tropicssl/: bignum.c rsa.c
  group ZC/src/zc
    ZC/src/zc/: zc_bc.c zc_client_manager.c zc_cloud_event.c zc_common.c zc_configuration.c zc_message_queue.c zc_moudle_manager.c zc_protocol_controller.c zc_sec_engine.c zc_timer.c
